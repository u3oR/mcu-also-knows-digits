# Keil uVision project stm32-project.uvprojx, settings and files
target stm32-project (6210000::V6.21::.\ARMCLANG_621)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32-project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__FPU_PRESENT=1U,__TARGET_FPU_VFP,ARM_MATH_LOOPUNROLL
  c misc: -Wgnu-folding-constant
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../UserApp;../UserApp/libs/FreeRTOS/include;../UserApp/libs/FreeRTOS/portable/GCC/ARM_CM7/r0p1;../UserApp/libs/FreeRTOS/portable/MemMang;../UserApp/libs/CMSIS/NN/Include;../UserApp/libs/CMSIS/DSP-1.15.0/Include;../Middlewares/ST/AI/Inc;../X-CUBE-AI/App;../X-CUBE-AI;Middlewares/ST/AI/Inc;X-CUBE-AI/App
  memory RVCT1: ROM 0x90000000 size 0x2000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32-project.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c fmc.c quadspi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_qspi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group FreeRTOS/Core
    ../UserApp/libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ../UserApp/libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../UserApp/libs/FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
  group CMSIS/DSP
    ../UserApp/libs/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib README.md
    ../UserApp/libs/CMSIS/DSP-1.15.0/Lib/ARM/: arm_cortexM7lfdp_math_15.lib
    ../UserApp/libs/CMSIS/DSP/Source/: ComputeLibrary.c
  group CMSIS/NN
    ../UserApp/libs/CMSIS/NN/Source/: NeuralNetwork.c
  group Application/Utils
    ../UserApp/utils/mnist_test_data/: mnist_test_data.c
  group Application/Test
    ../UserApp/test/: test_sdram.c test_armath.c test_qspiflash.c
  group Application/BSP
    ../UserApp/bsp/: bsp_sdram.c bsp_qspi_flash.c bsp_uart_debug.c
  group Application/UserApp
    ../UserApp/: user_main.c FreeRTOSConfig.h
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: mnist.c mnist_data.c mnist_data_params.c app_x-cube-ai.c
  group Doc
    ../X-CUBE-AI/App/: mnist_generate_report.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM7_Keil.lib
software components: CMSIS:CORE 5.6.0
